# Repository cillian64/smalltime

File README.md:

# smalltime
Little LED desk clock with TCXO RTC

## KiCad design board/smalltime.kicad_pcb

Parts:
BT1: CR1220/1225; KEYSTONE500; Farnell 3029839
C1: 10n; 0603; Farnell 1759102
C2, C7, C8: 1u; 0603; Farnell 1759399
C3: 4u7; 0603; Farnell 2320811
C4, C5, C6: 100n; 0603; Farnell 2627427
IC1: STM32F030K6T6; LQFP-32; Farnell 2432085
IC2: DS3231MZ; SOIC-8; Farnell 2515358
IC3: ADP3338; SOT223; Farnell 1651284
J1: MICROUSB; MICROUSB_MOLEX_47589-0001; Farnell 1568023
P1: SWD; FTSH-105-01-F-D-K
P2: SWD_TC; TC2030-NL
Q1: TEPT4400; LED_D3.0mm; Farnell SC12389
Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9: Q_NMOS_GSD; SOT-23; Farnell 1426253
R1, R2: 1k; 0603
R3: 100k; 0603; Farnell 2447226
R4, R5, R6, R7, R8, R9, R10, R11: 160; 0603; Farnell 2447260
SW1: INC; SKHHLSA010; Farnell 2056829
SW2: SET; SKHHLSA010; Farnell 2056829
TP1: SDA; testpoint
TP2: SCL; testpoint
TP3: GND; testpoint
U1: DIG1; LS0803GWK; Farnell 2627651
U2: DIG2; LS0803GWK; Farnell 2627651
U3: DIG3; LS0803GWK; Farnell 2627651
U4: DIG4; LS0803GWK; Farnell 2627651
U5: DIG5; LS0803GWK; Farnell 2627651
U6: DIG6; LS0803GWK; Farnell 2627651
U7: DIG7; LS0803GWK; Farnell 2627651
U8: DIG8; LS0803GWK; Farnell 2627651
X1: BATTERY; Farnell 4199091

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C8.1, IC1.1 (VDD), IC1.5 (VDDA), IC1.17 (VDD), IC2.2 (VCC), IC3.2 (VOUT), P1.1 (VTref), P2.1 (VDD), R1.1, R2.1
+5V: C7.1, IC3.3 (VIN), J1.1 (VCC)
/DIG1: IC1.25 (PA15), Q2.1 (G)
/DIG2: IC1.6 (PA0), Q3.1 (G)
/DIG3: IC1.3 (PF1), Q4.1 (G)
/DIG4: IC1.2 (PF0), Q5.1 (G)
/DIG5: IC1.11 (PA5), Q6.1 (G)
/DIG6: IC1.20 (PA10), Q7.1 (G)
/DIG7: IC1.8 (PA2), Q8.1 (G)
/DIG8: IC1.7 (PA1), Q9.1 (G)
/I2C_SCL: IC1.29 (PB6), IC2.8 (SCL), R2.2, TP2.1
/I2C_SDA: IC1.30 (PB7), IC2.7 (SDA), R1.2, TP1.1
/LIGHT_EN: IC1.9 (PA3), Q1.2 (C)
/LIGHT_SENSE: IC1.10 (PA4), Q1.1 (E), R3.1
/SEG_A: R4.1, U1.7 (A), U2.7 (A), U3.7 (A), U4.7 (A), U5.7 (A), U6.7 (A), U7.7 (A), U8.7 (A)
/SEG_B: R5.1, U1.6 (B), U2.6 (B), U3.6 (B), U4.6 (B), U5.6 (B), U6.6 (B), U7.6 (B), U8.6 (B)
/SEG_C: R6.1, U1.4 (C), U2.4 (C), U3.4 (C), U4.4 (C), U5.4 (C), U6.4 (C), U7.4 (C), U8.4 (C)
/SEG_D: R7.1, U1.2 (D), U2.2 (D), U3.2 (D), U4.2 (D), U5.2 (D), U6.2 (D), U7.2 (D), U8.2 (D)
/SEG_DP: R11.1, U1.5 (DP), U2.5 (DP), U3.5 (DP), U4.5 (DP), U5.5 (DP), U6.5 (DP), U7.5 (DP), U8.5 (DP)
/SEG_E: R8.1, U1.1 (E), U2.1 (E), U3.1 (E), U4.1 (E), U5.1 (E), U6.1 (E), U7.1 (E), U8.1 (E)
/SEG_F: R9.1, U1.9 (F), U2.9 (F), U3.9 (F), U4.9 (F), U5.9 (F), U6.9 (F), U7.9 (F), U8.9 (F)
/SEG_G: R10.1, U1.10 (G), U2.10 (G), U3.10 (G), U4.10 (G), U5.10 (G), U6.10 (G), U7.10 (G), U8.10 (G)
/SWCLK: IC1.24 (PA14), P1.4 (SWDCLK/TCK), P2.4 (SWDCLK)
/SWDIO: IC1.23 (PA13), P1.2 (SWDIO/TMS), P2.2 (SWDIO)
/SW_INC: IC1.18 (PA8), SW1.1
/SW_SET: IC1.19 (PA9), SW2.1
/~RST: IC1.4 (NRST), P1.10 (nRESET), P2.3 (~RST)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, IC1.16 (VSS), IC1.31 (BOOT0), IC1.32 (VSS), IC2.5 (GND), IC3.1 (GND), J1.5 (GND), P1.3 (GND), P1.5 (GND), P1.9 (GND), P2.5 (GND), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), R3.2, SW1.2, SW2.2, TP3.1
unnamed: BT1.1 (+), IC2.6 (VBAT)
unnamed: IC1.12 (PA6), R8.2
unnamed: IC1.13 (PA7), R7.2
unnamed: IC1.14 (PB0), R6.2
unnamed: IC1.15 (PB1), R11.2
unnamed: IC1.22 (PA12), R5.2
unnamed: IC1.26 (PB3), R4.2
unnamed: IC1.27 (PB4), R9.2
unnamed: IC1.28 (PB5), R10.2
unnamed: Q2.3 (D), U1.3 (CATH), U1.8 (CATH)
unnamed: Q3.3 (D), U2.3 (CATH), U2.8 (CATH)
unnamed: Q4.3 (D), U3.3 (CATH), U3.8 (CATH)
unnamed: Q5.3 (D), U4.3 (CATH), U4.8 (CATH)
unnamed: Q6.3 (D), U5.3 (CATH), U5.8 (CATH)
unnamed: Q7.3 (D), U6.3 (CATH), U6.8 (CATH)
unnamed: Q8.3 (D), U7.3 (CATH), U7.8 (CATH)
unnamed: Q9.3 (D), U8.3 (CATH), U8.8 (CATH)

Notes on the sheet:
VDDA
VDD

Board: 2 copper layers, 80.0 x 56.0 mm, 48 parts (8 on the bottom side), 45 nets.

## Code that names these connections

File firmware/board.yaml:

name: smalltime
lsefreq: 0
hsefreq: 0
voltage: 3.3
mcutype: STM32F051x8
default: input, pushpull, startlow, floating, highspeed
pins:
    DIG1:        pa15, output
    DIG2:        pa0,  output
    DIG3:        pf1,  output
    DIG4:        pf0,  output
    DIG5:        pa5,  output
    DIG6:        pa10, output
    DIG7:        pa2,  output
    DIG8:        pa1,  output

    SEG_A:       pb3,  output
    SEG_B:       pa12, output
    SEG_C:       pb0,  output
    SEG_D:       pa7,  output
    SEG_E:       pa6,  output
    SEG_F:       pb4,  output
    SEG_G:       pb5,  output
    SEG_DP:      pb1,  output

    LIGHT_EN:    pa3, output
    LIGHT_SENSE: pa4, analog

    I2C_SCL:     pb6, af1, opendrain
    I2C_SDA:     pb7, af1, opendrain

    SW_INC:      pa8, input, pullup
    SW_SET:      pa9, input, pullup

    SWDIO:       pa13, af0
    SWCLK:       pa14, af0

## Commit log

2017-07-19 added agg-kicad
2017-07-19 board initial commit
2017-07-21 bump agg-kicad for ds3231
2017-07-22 Added all parts to schematic
2017-07-24 Added values and order codes
2017-07-24 Added part number for push switches
2017-07-24 Added footprints for 7seg display and switches
2017-07-26 initial board outline
2017-07-26 bigger 7segs, better LDO, NFETs, CR1220
2017-07-26 removed unnecessary pullups
2017-07-27 Flipped and routed 7segs
2017-07-27 Did some more routing.
2017-07-31 Nominally finished routing
2017-07-31 minor routing improvements
2017-08-01 Schematic checking/finishing
2017-08-01 Finishing touches and checking, silk
2017-08-02 Add 1kR order#, add BOM
2017-08-03 Add submodule ChibiOS @ 85a55d8
2017-08-03 Barebones firmware compiles
2017-08-04 Replace STM32F030K6 with STM32F051K6 for more RAM
2017-08-04 Change ST support to 32bit timer on TIM2
2017-08-04 firmware layout
2017-08-04 Roughed out parts of firmware
2017-08-11 laser cut case
2017-08-18 case r2
2017-08-18 put swdio/swclk in board.h
2017-08-19 Display strobing works
2017-08-19 ds3231 driver
2017-08-19 Basic time/date setting
2017-08-19 Year set/display
2017-08-19 better second display/setter
2017-08-19 Removed redundant displaytime structure
2017-08-19 paste dxf and stickerbom pdf
2017-11-24 Add photo to README.md
2019-03-02 Change ADP3338 to 3v3 part
    BOM accidentally had 5V output ADP3338: change farnell part to 3v3 one.
2019-03-11 Initial checkin of rust cortex-m template
2019-03-12 Set cargo feature + ds323x crate
2019-03-12 Fix linker map flash location
2019-03-12 Flash LED... maybe
2019-03-13 New display pins struct without generics, board.rs
2019-03-14 Nicer display driver with object!
2021-12-20 Update dependencies
    Also checkin Cargo.lock and handle unused Results returned from
    set_high() and set_low()
2021-12-20 Add blackmagic probe flash script
2021-12-20 Basic demo: flash some segments on a single digit
2021-12-20 Setup 7-segment display font
    * Fix segment pin assignments, the datasheet lied
    * Type in 7-segment font
    * Demo which counts up digits 0-9 on one digit
2021-12-21 Arrange digits, handle flipping
    * Reorder digit locations so that 0 is top-left and 7 is bottom right.
    * The top 4 segments (0-3) are intentionally mounted upside-down on the
    PCB and so some segments need swapping so as to rotate the font by 180
    degrees.
2021-12-21 Setup I2C, simple DS3231 demo
    * Add I2C initialisation to board_setup
    * Setup DS3231 driver
    * Basic demo reading time from the DS3231 and rendering to the display
2021-12-21 Improve demo display
    * Turn off segments before changing which digit is selected, to prevent
    ghosting between adjacent digits
    * Turn off all segments before talking I2C to the DS3231, otherwise the
    final digit appears to flash slightly brighter due to being left on
    longer than the others.
